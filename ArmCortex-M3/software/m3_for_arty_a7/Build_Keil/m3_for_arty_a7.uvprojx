# Keil uVision project m3_for_arty_a7.uvprojx, settings and files
target m3_for_arty_a7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: m3_for_arty_a7 +hex
  AfterMake: V:\software\m3_for_arty_a7\Build_Keil\make_hex_a7.bat
  c flags: Optim=2 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 ARTY_CM3
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM3;..\main;..\gpio;..\uart;..\spi;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
  group CMSIS
    ../cmsis/Device/Source/ARTY_CM3/: system_ARTY_CM3.c
    ../cmsis/Device/Source/ARTY_CM3/ARM/: startup_ARTY_CM3.s
  group Main
    ../main/: atomic_asm.s main.c atomic.c
  group GPIO
    ../gpio/: gpio.c
  group SPI
    ../spi/: spi.c
  group UART
    ../uart/: uart.c
  group Xilinx_SPI
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/spi_v4_6/src/: xspi.c xspi_g.c xspi_options.c xspi_selftest.c xspi_sinit.c xspi_stats.c
  group Xilinx_UART
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/uartlite_v3_4/src/: xuartlite.c xuartlite_g.c xuartlite_intr.c xuartlite_l.c xuartlite_selftest.c xuartlite_sinit.c xuartlite_stats.c
  group Xilinx_GPIO
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/gpio_v4_6/src/: xgpio.c xgpio_extra.c xgpio_g.c xgpio_intr.c xgpio_selftest.c xgpio_sinit.c
  group Standalone_v7_2
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/standalone_v7_2/src/: outbyte.c print.c xil_assert.c xil_printf.c
  group Xilinx_SYSMON
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/sysmon_v7_6/src/: xsysmon.c xsysmon_g.c xsysmon_intr.c xsysmon_selftest.c xsysmon_sinit.c
target m3_for_arty_a7_sim (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1 SIM_BUILD
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM1;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include;..\main;..\platform;..\gpio;..\uart;..\spi
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry=Reset_Handler
target m3_for_arty_a7_v2c (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 ARTY_CM3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.0.2
